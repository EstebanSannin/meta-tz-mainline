# use-head-next builds tzn-mqtt at AUTOREV, whose Cargo.lock needs crates that
# tzn-mqtt-crates.inc doesn't list. Keep the revision the crate list is for.
SRCREV:use-head-next = "452f6c710e5878a98bb775b9ffa57a7498c26c1e"
