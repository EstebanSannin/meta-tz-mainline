# U-Boot main at 2027.01-rc1 hangs in SPL on Verdin iMX8MP right after the
# banner. Pin to the v2026.10 release instead of AUTOREV.
SRCREV = "5508406582f6f7120dce0c4b3059819a41788db2"
